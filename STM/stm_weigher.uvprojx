# Keil uVision project stm_weigher.uvprojx, settings and files
target weigher (ARM-ADS)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm_weigher +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_HD
  c include: ..\..\MTools\STM32;..\..\MTools\STM32\startup;..\..\MTools\STM32\CM3;..\..\MTools\STM32\FWlib\inc;..\base
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group ASM
    ../../MTools/STM32/startup/: startup_stm32f10x_hd.s
  group User
    ./: main.c stm32f10x_it.c SCRectifier.c weigher.c motor.c exti.c flash.c timer.c
  group CMSYS
    ../../MTools/STM32/CM3/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../../MTools/STM32/FWlib/SRC/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c
  group LED
    ../../MTools/STM32/: led.c
  group USART
    ../../MTools/STM32/: modbus.c modbus.h usart.c
  group public
    ../base/: scalestype.h
